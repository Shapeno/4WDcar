# IAR project K60project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60D10; DEBUG
  ICCARM.CCIncludePath2: ..\LIB\drivers\K\inc; ..\LIB\startup\DeviceSupport; ..\LIB\startup\DeviceSupport\IAR-ARM; ..\LIB\startup\CoreSupport; Hardware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K60project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: README.txt
  group LIB/Driver
    ../LIB/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group LIB/Starup
    ../LIB/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../LIB/startup/DeviceSupport/: system_MK60D10.c
  group USER
    ./: main.c
  group USER/Hardware
    Hardware/: control.c driver.c led.c photosensor.c
